# Keil uVision project Project.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: stm32f10x_it.c main.c
  group FWLib
    ../../../../RV31/LIB/ST/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
  group Doc
    ./: readme.txt
target STM3210E-EVAL (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
